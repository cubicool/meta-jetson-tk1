DEPENDS_append_tegra = " linux-driver-package"
