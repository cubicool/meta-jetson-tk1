FILESEXTRAPATHS_prepend_jetson-tk1 := "${THISDIR}/${PN}:"
