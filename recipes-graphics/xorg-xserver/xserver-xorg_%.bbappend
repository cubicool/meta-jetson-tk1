# The NVidia driver needs this enabled.
PACKAGECONFIG_append = " xinerama "
