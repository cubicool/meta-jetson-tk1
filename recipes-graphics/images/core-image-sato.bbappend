IMAGE_INSTALL += "mesa-demos glmark2"


